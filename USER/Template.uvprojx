# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\HARDWARE\delay;..\FWLib\inc;..\HARDWARE\ADF4351;..\Soft\Task;..\HARDWARE\LCD;..\HARDWARE\usart;..\HARDWARE\sys;..\HARDWARE\BEEP;..\HARDWARE\KEY
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ../HARDWARE/delay/: delay.c
    ../HARDWARE/ADF4351/: ADF4351.c Freq_control.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/usart/: usart.c
    ../HARDWARE/sys/: sys.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/KEY/: key.c
